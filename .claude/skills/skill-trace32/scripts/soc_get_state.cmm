PRinTer.Area
WinPrint.PER

ENDDO