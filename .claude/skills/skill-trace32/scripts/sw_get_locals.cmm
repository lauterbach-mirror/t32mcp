PRinTer.Area
WinPrint.Var.Local

ENDDO