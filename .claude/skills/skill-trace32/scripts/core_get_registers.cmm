PRinTer.Area
WinPrint.Register

ENDDO