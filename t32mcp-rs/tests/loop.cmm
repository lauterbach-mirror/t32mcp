WHILE TRUE()
(
  WAIT 50.ms
)
ENDDO
