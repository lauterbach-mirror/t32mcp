PRinTer.Area
WinPrint.Frame

ENDDO